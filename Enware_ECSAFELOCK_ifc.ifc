Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2023-01-16T14:41:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 16 14:41:45 2023 * Host: DESKTOP-33MVG7M * Database: C:\Users\PC-041\AppData\Local\Temp\53871c31-19fe-4b3c-a4cf-44bb7e00ef49\1296a6c0-f722-4775-9261-e7ea5dfaf4c3\ifc * Database version: 5507 * Database creation date: Mon Jan 16 14:41:45 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 16 14:41:45 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 16 14:41:45 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcBuildingElementProxy: BT20SL, Enware_ECSAFELOCK_rfa:BT20SL:3448
In: Level 1
Type - Material: Stainless Steel, Brushed
Type - Pset_BuildingElementProxyCommon - Reference: BT20SL
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: BT20SL
Pset_BuildingElementProxyCommon - sets with these values: 2
